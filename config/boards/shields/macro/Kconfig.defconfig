## config/boards/shields/macro/Kconfig.defconfig
```kconfig
if SHIELD_MACRO

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "macro"

endif
```
